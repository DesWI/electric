File: shema.sch (EAGLE design)
At the start: 20 parts

Commit message: asd
Other:
- moved on the sheet: C0, C1, C2, C3, C4, C5, C6, C7, D1, D2, L1, RCS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
